Commit message: Add external wrench compesation

File: robots/hydrus_xi/urdf/maze.urdf (robot description, URDF)
Before this commit: robot maze, 0 links, 3 joints
Joints:
- removed joint frame_joint1
